LICENSE = "CLOSED"

SRC_URI = "git://github.com/ros2/tinyxml2_vendor.git;protocol=https;branch=ardent"
SRCREV = "84eddebcd65d140fecb71a5a0cb20c94cec60456"


S = "${WORKDIR}/git"

inherit ament
