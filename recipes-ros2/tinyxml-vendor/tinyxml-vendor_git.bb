LICENSE = "CLOSED"

SRC_URI = "git://github.com/ros2/tinyxml_vendor.git;protocol=https;branch=ardent"
SRCREV = "5530f58b8171a5dd09168c110df1efbf55fe72d9"


S = "${WORKDIR}/git"

inherit ament
